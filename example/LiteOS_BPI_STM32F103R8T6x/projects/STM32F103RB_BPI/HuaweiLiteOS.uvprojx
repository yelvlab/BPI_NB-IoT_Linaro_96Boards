# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,LOS_STM32F103RBTx,RAM_SIZE_LEVEL_1
  c include: ..\..\example\include;..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m3;..\..\kernel\cmsis;..\..\platform\STM32F103RB;..\..\user;..\..\BSP\STM32F103RBTx\Inc;..\..\BSP\STM32F103RBTx\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\BSP\STM32F103RBTx\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\BSP\STM32F103RBTx\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\BSP\STM32F103RBTx\Drivers\CMSIS\Include;..\..\peripheral
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/stm32f103rb
    ../../platform/STM32F103RB/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group BSP/STM32F103RBTx
    ../../BSP/STM32F103RBTx/Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
    ../../BSP/STM32F103RBTx/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group neulbc95
    ../../peripheral/: neul_bc95.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../BSP/STM32F103RBTx/MDK-ARM/: startup_stm32f103xb.s
  group user
    ../../user/: main.c max7219_driver_func.c los_dev_st_uart.c ocean_nb_sample.c
